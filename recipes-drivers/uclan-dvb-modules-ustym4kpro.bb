KV = "4.4.35"
SRCDATE = "20220424"

require uclan-dvb-modules-hisi.inc

SRC_URI[md5sum] = "fc43e8259a9c7763fdadb4123780aebc"
SRC_URI[sha256sum] = "6d9f30f8ea1311418712c42462b31402a7a50f7d98a54d0874eeedf918e8e94b"
